# Keil uVision project ARM_SDR.uvproj, settings and files
target ARM_SDR (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ARM_SDR
  AfterMake: fromelf.exe --bin .\Objects\ARM_SDR.axf --output .\Objects\ARM_SDR.bin
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM ARM_MATH_CM4 STM32F429xx STM32F429I_DISCOVERY __FPU_PRESENT
  c include: .\STM32F4xx_StdPeriph_Driver\inc;H:\Applications\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.4.0\Drivers\STM32F4xx_HAL_Driver\Inc;H:\Applications\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.4.0\MDK\Templates\Inc\;H:\Applications\Keil_v5\ARM\Pack\Keil\MDK-Middleware\6.4.0\emWin\Include\;H:\Applications\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.4.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include\;H:\Applications\Keil_v5\ARM\Pack\Keil\MDK-Middleware\6.4.0\Board;H:\Applications\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Driver\Include\;H:\Applications\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.4.0\CMSIS\Driver\;H:\Applications\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.4.0\Drivers\BSP\STM32F429I-Discovery;H:\Applications\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include\;.\
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f429_439xx.s system_stm32f4xx.c
  group Source Files
    ./: main.c SDR_func.c SDR_math.c SDR_InitPeriph.c
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_dac.c
  group Graphics
    H:/Applications/Keil_v5/ARM/Pack/Keil/MDK-Middleware/6.4.0/emWin/Lib/ARM/: GUI_CM4F_L.lib
    H:/Applications/Keil_v5/ARM/Pack/Keil/MDK-Middleware/6.4.0/emWin/Sample/GUI_X/: GUI_X_Ex.c
    ./: LED_F429Discovery.c GUIConf.c LCDConf.c LCD_X.c ili9341.c SDR_MainFormDLG.c I2C_STM32F4xx.c Touch_STMPE811.c GUI_X_Touch.c
  group System Files
    ./: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f429i_discovery.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c SPI_STM32F4xx.c stm32f4xx_hal_rcc_ex.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c
  group Libraries
    H:/Applications/Keil_v5/ARM/Pack/ARM/CMSIS/4.3.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib arm_cortexM4l_math.lib
